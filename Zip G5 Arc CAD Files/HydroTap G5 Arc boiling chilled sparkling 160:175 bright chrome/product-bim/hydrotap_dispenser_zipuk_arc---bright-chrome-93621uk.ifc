Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0], ExchangeRequirement []
File name: Project Number
Time: 2021-09-09T17:05:11
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 22.0.10.28 - Exporter 22.0.10.28 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Thu Sep 09 17:05:11 2021 * Host: DESKTOP-QB16J48 * Database: C:\Users\Glenn\AppData\Local\Temp\b05f7b85-a1d0-447a-9c05-9af200eb2c2b\84bcc1db-3888-4527-8246-1a3fb237eb51\ifc * Database version: 5507 * Database creation date: Thu Sep 09 17:05:11 2021 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Thu Sep 09 17:05:11 2021 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Thu Sep 09 17:05:11 2021 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: -33, -52, -1, -696472; RefLongitude: 151, 12, 25, 587158; RefElevation: 0 mm
Pset_ProductRequirements - Category: Project Information
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Pset_ProductRequirements - Category: Project Information
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcBuildingStorey: Level:8mm Head, Ground Floor
LongName: Ground Floor; Elevation: 0 mm
Other(Type) - Category: Levels; Family Name: Level
Pset_AirSideSystemInformation - Name: Ground Floor
Pset_ProductRequirements - Name: Ground Floor; Category: Levels
Constraints - Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: Ground Floor; Structural: no
Other - Category: Levels; Family: Level: 8mm Head; Family and Type: Level: 8mm Head; Type: Level: 8mm Head; Type Id: Level: 8mm Head
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Solid; Line Weight: 1; Symbol at End 1 Default: no; Symbol at End 2 Default: yes
Identity Data(Type) - Type Name: 8mm Head

# IfcElementAssembly: Plumbing Fixtures Assembly:HydroTap_Dispenser_ZipUK_Arc Bright Chrome (93621UK), Plumbing Fixtures Assembly:HydroTap_Dispenser_ZipUK_Arc Bright Chrome (93621UK):1497658
In: Ground Floor
PredefinedType: USERDEFINED
Pset_ProductRequirements - Category: Assemblies
Pset_QuantityTakeOff - Reference: HydroTap_Dispenser_ZipUK_Arc Bright Chrome (93621UK)
Identity Data - Naming Category: Plumbing Fixtures
Other - Category: Assemblies; Family: Plumbing Fixtures Assembly: HydroTap_Dispenser_ZipUK_Arc Bright Chrome (93621UK); Family and Type: Plumbing Fixtures Assembly: HydroTap_Dispenser_ZipUK_Arc Bright Chrome (93621UK); Type: Plumbing Fixtures Assembly: HydroTap_Dispenser_ZipUK_Arc Bright Chrome (93621UK); Type Id: Plumbing Fixtures Assembly: HydroTap_Dispenser_ZipUK_Arc Bright Chrome (93621UK)
Phasing - Phase Created: New Construction
Identity Data(Type) - Type Name: HydroTap_Dispenser_ZipUK_Arc Bright Chrome (93621UK)
Other(Type) - Category: Assemblies; Family Name: Plumbing Fixtures Assembly

# IfcFlowController: HydroTap_Dispenser_ZipUK_Arc:Bright Chrome (93621UK), HydroTap_Dispenser_ZipUK_Arc:Bright Chrome (93621UK):1492195
In: Ground Floor
Type - PredefinedType: FAUCET; Material: Metal_BrightChrome_Zip
Type - Constraints - Default Elevation: 0 mm
Type - Dimensions - Manufacturer_Overall Depth: 200 mm; Manufacturer_Overall Height: 353 mm; Manufacturer_Overall Width: 90 mm
Type - Identity Data - CreatedBy_ANZRS: IGS BIM Solutions; CreatedByURL_ANZRS: https://igsgroup.com.au; Description: HydroTap - Arc Tap; Manufacturer: Zip Water UK; Manufacturer_Spec Code: 93621UK; Manufacturer_URL__Product Specific: https://specify.zipwater.co.uk/our-ranges/hydrotap; Model: Z00; ModifiedIssue_ANZRS: 20210728; OmniClass Number: 23.31.11.00; Type Comments: Bright Chrome Finish; Type Name: Bright Chrome (93621UK); Uniclass2015Code: Pr_40_70_23_42; Uniclass2015Title: Instant boiling and cold water taps; Uniclass2015Version: Products v1.17; URL: https://www.zipwater.co.uk/
Type - Materials and Finishes - FixtureMaterial: Metal_BrightChrome_Zip
Type - Other - Category: Plumbing Fixtures; AccessibilityPerformance: n/a; AssetType: Fixed; CodePerformance: UKCA and CE marked; Color: Bright Chrome; Family Name: HydroTap_Dispenser_ZipUK_Arc; Grade: Commercial; Size: 90 x 200 x 353 mm; SustainabilityPerformance: RoHS and WEEE compliant
Type - Pset_ElementShading - Color: Bright Chrome
Type - Pset_ManufacturerTypeInformation - Manufacturer: Zip Water UK
Type - Pset_ProductRequirements - Category: Plumbing Fixtures
Pset_DistributionFlowElementCommon - Reference: Bright Chrome (93621UK); sets with these values: 2
Constraints - Elevation from Level: 0 mm; Offset from Host: 0 mm
Construction - Manufacturer_Height From FFL: 0 mm
Dimensions - Area: 0.074046 m2; Volume: 0.000623193 m3; WasteOutletVoid: -50 mm
Identity Data - Assembly Name: HydroTap_Dispenser_ZipUK_Arc Bright Chrome (93621UK); Mark: 208
Other - Family: HydroTap_Dispenser_ZipUK_Arc: Bright Chrome (93621UK); Family and Type: HydroTap_Dispenser_ZipUK_Arc: Bright Chrome (93621UK); Type: HydroTap_Dispenser_ZipUK_Arc: Bright Chrome (93621UK); Type Id: HydroTap_Dispenser_ZipUK_Arc: Bright Chrome (93621UK)
Phasing - Phase Created: New Construction
Visibility - Font: no
