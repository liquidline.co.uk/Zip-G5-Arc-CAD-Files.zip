Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0], ExchangeRequirement []
File name: Project Number
Time: 2021-09-09T17:05:10
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 22.0.10.28 - Exporter 22.0.10.28 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Thu Sep 09 17:05:10 2021 * Host: DESKTOP-QB16J48 * Database: C:\Users\Glenn\AppData\Local\Temp\b05f7b85-a1d0-447a-9c05-9af200eb2c2b\f4e6be86-32aa-40fb-b612-75807c43e70b\ifc * Database version: 5507 * Database creation date: Thu Sep 09 17:05:09 2021 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Thu Sep 09 17:05:10 2021 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Thu Sep 09 17:05:10 2021 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: -33, -52, -1, -696472; RefLongitude: 151, 12, 25, 587158; RefElevation: 0 mm
Pset_ProductRequirements - Category: Project Information
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Pset_ProductRequirements - Category: Project Information
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcBuildingStorey: Level:8mm Head, Ground Floor
LongName: Ground Floor; Elevation: 0 mm
Other(Type) - Category: Levels; Family Name: Level
Pset_AirSideSystemInformation - Name: Ground Floor
Pset_ProductRequirements - Name: Ground Floor; Category: Levels
Constraints - Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: Ground Floor; Structural: no
Other - Category: Levels; Family: Level: 8mm Head; Family and Type: Level: 8mm Head; Type: Level: 8mm Head; Type Id: Level: 8mm Head
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Solid; Line Weight: 1; Symbol at End 1 Default: no; Symbol at End 2 Default: yes
Identity Data(Type) - Type Name: 8mm Head

# IfcDistributionPort (2)
Description: Flow
Name | FlowDirection
Port_1492189 | SOURCEANDSINK
Port_1492189 | SOURCE

# IfcElementAssembly: Plumbing Fixtures Assembly:HydroTap_CommandCentre_ZipUK 395w x 464d x 333h (BCS), Plumbing Fixtures Assembly:HydroTap_CommandCentre_ZipUK 395w x 464d x 333h (BCS):1497652
In: Ground Floor
PredefinedType: USERDEFINED
Pset_ProductRequirements - Category: Assemblies
Pset_QuantityTakeOff - Reference: HydroTap_CommandCentre_ZipUK 395w x 464d x 333h (BCS)
Identity Data - Naming Category: Plumbing Fixtures
Other - Category: Assemblies; Family: Plumbing Fixtures Assembly: HydroTap_CommandCentre_ZipUK 395w x 464d x 333h (BCS); Family and Type: Plumbing Fixtures Assembly: HydroTap_CommandCentre_ZipUK 395w x 464d x 333h (BCS); Type: Plumbing Fixtures Assembly: HydroTap_CommandCentre_ZipUK 395w x 464d x 333h (BCS); Type Id: Plumbing Fixtures Assembly: HydroTap_CommandCentre_ZipUK 395w x 464d x 333h (BCS)
Phasing - Phase Created: New Construction
Identity Data(Type) - Type Name: HydroTap_CommandCentre_ZipUK 395w x 464d x 333h (BCS)
Other(Type) - Category: Assemblies; Family Name: Plumbing Fixtures Assembly

# IfcFlowTerminal: HydroTap_CommandCentre_ZipUK:395w x 464d x 333h (BCS), HydroTap_CommandCentre_ZipUK:395w x 464d x 333h (BCS):1492189
In: Ground Floor
Type - Material: Red_Zip
Type - Constraints - Default Elevation: 1219.2 mm
Type - Dimensions - Manufacturer_Overall Depth: 464 mm; Manufacturer_Overall Height: 333 mm; Manufacturer_Overall Width: 395 mm
Type - Identity Data - CreatedBy_ANZRS: IGS BIM Solutions; CreatedByURL_ANZRS: https://igsgroup.com.au; Description: HydroTap - Under Counter Command Centre including full colour interactive touch screen display with pin code protection.; Manufacturer: Zip Water UK; Manufacturer_Spec Code: H50062000UK; Manufacturer_URL__Product Specific: https://specify.zipwater.co.uk/our-ranges/hydrotap; Model: 395w x 464d x 333h - BCS; ModifiedIssue_ANZRS: 20210826; OmniClass Number: 23.21.21.13.13; Type Comments: Boiling, Chilled, Sparkling Filtered Water; Type Name: 395w x 464d x 333h (BCS); Uniclass2015Code: Pr_40_70_23_42; Uniclass2015Title: Instant boiling and cold water taps; Uniclass2015Version: Products v1.17; URL: https://www.zipwater.co.uk/
Type - Other - Category: Plumbing Fixtures; AccessibilityPerformance: n/a; AirFilterBaseOffset: 55 mm; AirFilterDepth: 258 mm; AirFilterFrontOffset: 66 mm; AirFilterWidth: 177 mm; AssetType: Fixed; B: no; BA_BHA: no; BC_BCHA: no; BC_BCHA_WithDuct: no; BCS_BCSHA: no; BCS_BCSHA_WithDuct: yes; BodyFrontOffset: 62 mm; C: no; C_CHA_WithDuct: no; CodePerformance: UKCA and CE marked; ColdWaterOffset: 192.3 mm; ColdWaterOffsetCalc: 178.5 mm; Color: White; CS: no; CS_CSHA_WithDuct: no; Duct_Left: no; Duct_Right: yes; ElectricalOffset: 376 mm; ElectricalOffsetCalc: 367.1 mm; Family Name: HydroTap_CommandCentre_ZipUK; FrontPanel: yes; Grade: Commercial; Size: 395 x 464 x 333 mm; SustainabilityPerformance: RoHS and WEEE compliant; VentedFrontPanel: no
Type - Visibility - AirFilter_Left: yes; AirFilter_Right: no
Type - Pset_ElementShading - Color: White
Type - Pset_ManufacturerTypeInformation - Manufacturer: Zip Water UK
Type - Pset_ProductRequirements - Category: Plumbing Fixtures
Material: Metal_PowderCoat_Zip_White, Black_Zip
Pset_DistributionFlowElementCommon - Reference: 395w x 464d x 333h (BCS); sets with these values: 2
Constraints - Elevation from Level: 0 mm; Offset from Host: 0 mm
Dimensions - Area: 1.69328 m2; Volume: 0.194964 m3
Identity Data - Assembly Name: HydroTap_CommandCentre_ZipUK 395w x 464d x 333h (BCS); Mark: 202
Mechanical - System Classification: Power,Domestic Cold Water
Other - Family: HydroTap_CommandCentre_ZipUK: 395w x 464d x 333h (BCS); Family and Type: HydroTap_CommandCentre_ZipUK: 395w x 464d x 333h (BCS); Type: HydroTap_CommandCentre_ZipUK: 395w x 464d x 333h (BCS); Type Id: HydroTap_CommandCentre_ZipUK: 395w x 464d x 333h (BCS)
Phasing - Phase Created: New Construction
Visibility - RequiredSpace: yes
