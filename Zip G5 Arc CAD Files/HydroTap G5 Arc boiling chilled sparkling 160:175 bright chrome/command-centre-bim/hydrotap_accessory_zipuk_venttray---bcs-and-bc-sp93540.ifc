Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0], ExchangeRequirement []
File name: Project Number
Time: 2021-09-09T17:04:50
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 22.0.10.28 - Exporter 22.0.10.28 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Thu Sep 09 17:04:50 2021 * Host: DESKTOP-QB16J48 * Database: C:\Users\Glenn\AppData\Local\Temp\b05f7b85-a1d0-447a-9c05-9af200eb2c2b\2af331ad-cb5d-414f-840d-e75e2eb24206\ifc * Database version: 5507 * Database creation date: Thu Sep 09 17:04:50 2021 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Thu Sep 09 17:04:50 2021 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Thu Sep 09 17:04:50 2021 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: -33, -52, -1, -696472; RefLongitude: 151, 12, 25, 587158; RefElevation: 0 mm
Pset_ProductRequirements - Category: Project Information
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Pset_ProductRequirements - Category: Project Information
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcBuildingStorey: Level:8mm Head, Ground Floor
LongName: Ground Floor; Elevation: 0 mm
Other(Type) - Category: Levels; Family Name: Level
Pset_AirSideSystemInformation - Name: Ground Floor
Pset_ProductRequirements - Name: Ground Floor; Category: Levels
Constraints - Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: Ground Floor; Structural: no
Other - Category: Levels; Family: Level: 8mm Head; Family and Type: Level: 8mm Head; Type: Level: 8mm Head; Type Id: Level: 8mm Head
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Solid; Line Weight: 1; Symbol at End 1 Default: no; Symbol at End 2 Default: yes
Identity Data(Type) - Type Name: 8mm Head

# IfcElementAssembly: Plumbing Fixtures Assembly:HydroTap_Accessory_ZipUK_VentTray BCS and BC (SP93540), Plumbing Fixtures Assembly:HydroTap_Accessory_ZipUK_VentTray BCS and BC (SP93540):1497648
In: Ground Floor
PredefinedType: USERDEFINED
Pset_ProductRequirements - Category: Assemblies
Pset_QuantityTakeOff - Reference: HydroTap_Accessory_ZipUK_VentTray BCS and BC (SP93540)
Identity Data - Naming Category: Plumbing Fixtures
Other - Category: Assemblies; Family: Plumbing Fixtures Assembly: HydroTap_Accessory_ZipUK_VentTray BCS and BC (SP93540); Family and Type: Plumbing Fixtures Assembly: HydroTap_Accessory_ZipUK_VentTray BCS and BC (SP93540); Type: Plumbing Fixtures Assembly: HydroTap_Accessory_ZipUK_VentTray BCS and BC (SP93540); Type Id: Plumbing Fixtures Assembly: HydroTap_Accessory_ZipUK_VentTray BCS and BC (SP93540)
Phasing - Phase Created: New Construction
Identity Data(Type) - Type Name: HydroTap_Accessory_ZipUK_VentTray BCS and BC (SP93540)
Other(Type) - Category: Assemblies; Family Name: Plumbing Fixtures Assembly

# IfcFlowTerminal: HydroTap_Accessory_ZipUK_VentTray:BCS and BC (SP93540), HydroTap_Accessory_ZipUK_VentTray:BCS and BC (SP93540):1492185
In: Ground Floor
Type - Material: White_Zip
Type - Constraints - Default Elevation: 0 mm
Type - Dimensions - Manufacturer_Overall Depth: 520 mm; Manufacturer_Overall Height: 40 mm; Manufacturer_Overall Width: 500 mm
Type - Identity Data - CreatedBy_ANZRS: IGS BIM Solutions; CreatedByURL_ANZRS: https://igsgroup.com.au; Description: Vent Tray for HydroTap Command Centre; Manufacturer: Zip Water UK; Manufacturer_Spec Code: SP93540; Manufacturer_URL__Product Specific: https://specify.zipwater.co.uk/our-ranges/hydrotap; Model: Vent Tray - BCS and BC; ModifiedIssue_ANZRS: 20210826; OmniClass Number: 23.21.21.13.13; Type Comments: Use with BCS and BC Command Centres; Type Name: BCS and BC (SP93540); Uniclass2015Code: Pr_40_70_23_42; Uniclass2015Title: Instant boiling and cold water taps; Uniclass2015Version: Products v1.17; URL: https://www.zipwater.co.uk/
Type - Other - Category: Plumbing Fixtures; AccessibilityPerformance: n/a; AssetType: Fixed; CodePerformance: n/a; Color: White; Family Name: HydroTap_Accessory_ZipUK_VentTray; Grade: Commercial; Size: 500 x 520 x 40 mm; SustainabilityPerformance: n/a
Type - Pset_ElementShading - Color: White
Type - Pset_ManufacturerTypeInformation - Manufacturer: Zip Water UK
Type - Pset_ProductRequirements - Category: Plumbing Fixtures
Pset_DistributionFlowElementCommon - Reference: BCS and BC (SP93540); sets with these values: 2
Constraints - Elevation from Level: 0 mm; ManufacturerHeightFromFFL: 0 mm; Offset from Host: 0 mm
Dimensions - Area: 0.296164 m2; Volume: 0.0102283 m3
Identity Data - Assembly Name: HydroTap_Accessory_ZipUK_VentTray BCS and BC (SP93540); Mark: 198
Other - Family: HydroTap_Accessory_ZipUK_VentTray: BCS and BC (SP93540); Family and Type: HydroTap_Accessory_ZipUK_VentTray: BCS and BC (SP93540); Type: HydroTap_Accessory_ZipUK_VentTray: BCS and BC (SP93540); Type Id: HydroTap_Accessory_ZipUK_VentTray: BCS and BC (SP93540)
Phasing - Phase Created: New Construction
